EXCLUDE_FROM_WORLD = "1"
