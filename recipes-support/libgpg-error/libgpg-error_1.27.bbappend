FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI += "file://0001-syscfg-Add-a-riscv64-architecture.patch"
