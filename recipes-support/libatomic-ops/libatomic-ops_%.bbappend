# risc-v support is not in release yet
SRCBRANCH_riscv32 = "master"
SRCBRANCH_riscv64 = "master"

SRCREV_riscv32 = "393d7a7ff54565230f44e59a9c73addc9e627f56"
SRCREV_riscv64 = "393d7a7ff54565230f44e59a9c73addc9e627f56"

SRCREV_FORMAT = "${PN}"
