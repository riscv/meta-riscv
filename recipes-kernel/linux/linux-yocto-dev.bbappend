COMPATIBLE_MACHINE_append = "|qemuriscv32"
