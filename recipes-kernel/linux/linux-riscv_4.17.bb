require recipes-kernel/linux/linux-riscv-common.inc

LIC_FILES_CHKSUM = "file://${S}/COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"

LINUX_VERSION ?= "4.17-rc2"

BRANCH = "riscv-all"
SRCREV = "98d9b42f35ff124df8bc9a466c3fb2b41547a94d"
