DEPENDS_append_class-target = " beecrypt"
EXTRA_OECONF_append_class-target = " --with-crypto=beecrypt"

