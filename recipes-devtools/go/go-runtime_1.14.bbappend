FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

require go-riscv.inc

