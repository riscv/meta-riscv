require u-boot-d1.inc
FILESEXTRAPATHS:prepend = "${FILE_DIRNAME}/u-boot-nezha:"

COMPATIBLE_MACHINE = "mangopi-mq-pro"
UBOOT_MACHINE = "mangopi_mq_pro_defconfig"
