FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_beaglev-starlight-jh7100 = " \
            file://926215b268f6e1502f53af992ead5da466f950a8.patch \
           "
