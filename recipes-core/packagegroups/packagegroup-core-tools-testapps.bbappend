FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

GSTEXAMPLES:riscv32 = ""
