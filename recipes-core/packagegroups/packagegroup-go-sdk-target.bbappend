COMPATIBLE_HOST_riscv64 = "riscv64*"
COMPATIBLE_HOST_riscv32 = "null"
