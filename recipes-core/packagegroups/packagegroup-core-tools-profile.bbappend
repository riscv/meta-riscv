FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SYSTEMTAP_riscv32 = ""
VALGRIND_riscv32 = ""
