SRCBRANCH_qemuriscv32 = "master"
SRCREV_glibc_qemuriscv32 = "567b1705017a0876b1cf9661a20521ef1e4ddc54"
