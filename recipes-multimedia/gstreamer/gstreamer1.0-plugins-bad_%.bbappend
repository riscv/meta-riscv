PACKAGECONFIG:append:jh7110 = " kms"
