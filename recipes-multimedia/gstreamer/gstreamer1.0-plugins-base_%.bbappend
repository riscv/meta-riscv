OPENGL_PLATFORMS:jh7110 = "egl"
PACKAGECONFIG_GL:jh7110 = "gles2 egl"
