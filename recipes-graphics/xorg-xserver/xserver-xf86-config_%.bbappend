# provide visionfive2 specific X11 config
FILESEXTRAPATHS:prepend:jh7110 := "${THISDIR}/${PN}:"
