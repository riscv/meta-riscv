RDEPENDS:${PN}:append:jh7110 = " \
    xf86-video-modesetting \
    ${PN}-extension-glx \
    xserver-xf86-config \
"
